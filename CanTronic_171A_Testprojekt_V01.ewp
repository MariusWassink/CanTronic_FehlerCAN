# IAR project CanTronic_171A_Testprojekt_V01.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52618 R5F52618
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: RX261
  ICCRX.CCIncludePath2: src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg; src\smc_gen\Config_CMT0; src\smc_gen\Config_PORT; src\smc_gen\Config_RSPI0; src\smc_gen\r_canfd_rx; src\smc_gen\r_canfd_rx\src; src\smc_gen\r_canfd_rx\inc; src\smc_gen\r_canfd_rx\inc; src; src\smc_gen\r_flash_rx; src\smc_gen\r_flash_rx\src; src\smc_gen\r_flash_rx\src\flash_type_1; src\smc_gen\r_flash_rx\src\flash_type_3; src\smc_gen\r_flash_rx\src\flash_type_4; src\smc_gen\r_flash_rx\src\flash_type_5; src\smc_gen\r_flash_rx\src\targets; src\smc_gen\Config_S12AD0; src\smc_gen\r_lpc_rx; src\smc_gen\r_lpc_rx\src
  ICCRX.IccExtraOptions: --joined_bitfields
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: CanTronic_171A_Testprojekt_V01.srec
  ILINK.IlinkOutputFile: CanTronic_171A_Testprojekt_V01.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg; src\smc_gen\Config_CMT0; src\smc_gen\Config_PORT; src\smc_gen\Config_RSPI0; src\smc_gen\r_canfd_rx; src\smc_gen\r_canfd_rx\src; src\smc_gen\r_canfd_rx\inc; src\smc_gen\r_flash_rx; src\smc_gen\r_flash_rx\src; src\smc_gen\r_flash_rx\src\flash_type_1; src\smc_gen\r_flash_rx\src\flash_type_3; src\smc_gen\r_flash_rx\src\flash_type_4; src\smc_gen\r_flash_rx\src\flash_type_5; src\smc_gen\r_flash_rx\src\targets; src\smc_gen\Config_S12AD0; src\smc_gen\r_lpc_rx; src\smc_gen\r_lpc_rx\src
  group (top)
    ./: buildinfo.ipcf
    src/: can.c can.h main.c main.h portdefine.h
  group Renesas_AP/src/smc_gen/Config_CMT0
    src/smc_gen/Config_CMT0/: Config_CMT0.c Config_CMT0.h Config_CMT0_user.c
  group Renesas_AP/src/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_AP/src/smc_gen/general
    src/smc_gen/general/: r_cg_cmt.h r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_port.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/src/smc_gen/r_bsp/board/generic_rx261
    src/smc_gen/r_bsp/board/generic_rx261/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h
  group Renesas_AP/src/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0771-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0771-rx-bsp.pdf
  group Renesas_AP/src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: fsp_common_api.h iar_call_inits.s lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_fsp_error.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx261
    src/smc_gen/r_bsp/mcu/rx261/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/src/smc_gen/r_bsp/mcu/rx261/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx261/register_access/iccrx/: iodefine.h
  group Renesas_AP/src/smc_gen/r_canfd_rx
    src/smc_gen/r_canfd_rx/: r_canfd_rx_if.h readme.txt
  group Renesas_AP/src/smc_gen/r_canfd_rx/doc/en
    src/smc_gen/r_canfd_rx/doc/en/: r01an6130es0152-rx-canfd.pdf
  group Renesas_AP/src/smc_gen/r_canfd_rx/doc/ja
    src/smc_gen/r_canfd_rx/doc/ja/: r01an6130js0152-rx-canfd.pdf
  group Renesas_AP/src/smc_gen/r_canfd_rx/inc
    src/smc_gen/r_canfd_rx/inc/: r_can_api.h r_canfd.h
  group Renesas_AP/src/smc_gen/r_canfd_rx/src
    src/smc_gen/r_canfd_rx/src/: r_canfd_data.c r_canfd_rx.c r_canfd_rx_private.h
  group Renesas_AP/src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_canfd_rx_config.h
  group Renesas_AP/src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_canfd_rx_pinset.c r_canfd_rx_pinset.h r_pinset.h
