<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\CanTronic_171A_Testprojekt_V01.ewp</path>
    </project>
    <batchBuild/>
</workspace>